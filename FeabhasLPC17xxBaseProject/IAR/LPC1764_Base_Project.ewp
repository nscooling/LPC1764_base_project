# IAR project LPC1764_Base_Project.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC1764 NXP LPC1764
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config\LPC1764_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config\LPC1764_Ram.icf
  group bsp
    ./: cstartup_M.s low_level_init.c
  group src
    ../: main.c
