# Keil uVision project LPC1764_Base_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1764_Base_Project
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source Group 1
    ./: startup_LPC17xx.s system_LPC17xx.c
    ../: main.c serial.c
