# Keil uVision project baseProject.uvproj, settings and files
target STM32F107CV (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: baseProject
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./: startup_stm32f10x_cl.s
    ../STM32/Source/: system_stm32f10x_cl.c
  group src
    ../: main.c
